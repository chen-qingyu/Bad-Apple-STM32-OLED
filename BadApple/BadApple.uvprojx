# Keil uVision project BadApple.uvprojx, settings and files
target BadApple (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BadApple +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Hardwares;.\Libraries;.\Libraries\inc;.\Libraries\system;.\FATFS\fatfs;.\FATFS\exfuns;.\FATFS\fatfs\option;.\FATFS;.\USMART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./Sources/: main.c
  group Hardwares
    ./Hardwares/: spi.c w25qxx.c sdio_sdcard.c oled.c
  group Libraries
    ./Libraries/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ./Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_dma.c
    ./Libraries/system/: delay.c sys.c usart.c malloc.c
  group FATFS
    ./FATFS/fatfs/: ff.c diskio.c
    ./FATFS/fatfs/option/: cc936.c
    ./FATFS/exfuns/: exfuns.c fattester.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
